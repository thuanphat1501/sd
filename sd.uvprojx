# Keil uVision project sd.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: sd
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=1
  c include: .\STM32F103-SDCARD-master\BSP;.\STM32F103-SDCARD-master\Driver;.\STM32F103-SDCARD-master\Lib\sdlib;.\STM32F103-SDCARD-master\Middleware\FatFs\src;.\Delay
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Src
    ./STM32F103-SDCARD-master/: main.c
    ./STM32F103-SDCARD-master/BSP/: sdcard.c
    ./STM32F103-SDCARD-master/Driver/: gpio.c spi.c
    ./STM32F103-SDCARD-master/Middleware/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ./STM32F103-SDCARD-master/Lib/sdlib/: fatfs.c fatfs_sd.c user_diskio.c
    ./Delay/: delay.c
    ./STM32F103-SDCARD-master/Middleware/FatFs/src/option/: unicode.c
  group Inc
    ./STM32F103-SDCARD-master/Lib/sdlib/: fatfs.h fatfs_sd.h ffconf.h user_diskio.h
    ./STM32F103-SDCARD-master/Middleware/FatFs/src/: diskio.h ff.h ff_gen_drv.h
    ./STM32F103-SDCARD-master/Driver/: gpio.h spi.h
    ./STM32F103-SDCARD-master/BSP/: sdcard.h
    ./Delay/: delay.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:Framework 3.6.0, Device:StdPeriph Drivers:GPIO 3.6.0, Device:StdPeriph Drivers:RCC 3.6.0, Device:StdPeriph Drivers:SPI 3.6.0, Device:StdPeriph Drivers:TIM 3.6.0, Device:StdPeriph Drivers:USART 3.6.0
